int ledPin = 13; 
int state = 0;// on state vaiable
int flag = 0; // on flag variable
void setup() {
   pinMode(ledPin, OUTPUT);
 digitalWrite(ledPin, LOW);
 
 Serial.begin(9600);//default conncetion rate of the arduino
    
}

void loop() {
  if(Serial.available() > 0){
 state = Serial.read();// serial data to send it to the state variable
 flag=0;
 }

 if (state == '0') {
 digitalWrite(ledPin, LOW);
 if(flag == 0){
 Serial.println("LED: off");
 flag = 1;
 }
 }

 else if (state == '1') {
 digitalWrite(ledPin, HIGH);
 if(flag == 0){
 Serial.println("LED: on");
 flag = 1;
 }
 }
}
    
}
